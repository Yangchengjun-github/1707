# Keil uVision project user_project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: CS32F103VB ChipSea
  pack: ChipSea.CS32F1xx_DFP.2.1.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: user_project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CS32F103xB,
  c include: ..\Main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Main/: main.c cs32f10x_it.c init.c init.h adc.c app.c bms.c communication.c debug.c key.c led.c queue.c task.c iic.c bms_pro.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.1.0, Device:StdPeriph Drivers:ADC 2.1.0, Device:StdPeriph Drivers:BKP 2.1.0, Device:StdPeriph Drivers:CAN 2.1.0, Device:StdPeriph Drivers:CRC 2.1.0, Device:StdPeriph Drivers:DEBUG 2.1.0, Device:StdPeriph Drivers:DMA 2.1.0, Device:StdPeriph Drivers:EXTI 2.1.0, Device:StdPeriph Drivers:FWDT 2.1.0, Device:StdPeriph Drivers:Flash 2.1.0, Device:StdPeriph Drivers:Framework 2.1.0, Device:StdPeriph Drivers:GPIO 2.1.0, Device:StdPeriph Drivers:I2C 2.1.0, Device:StdPeriph Drivers:PMU 2.1.0, Device:StdPeriph Drivers:RCU 2.1.0, Device:StdPeriph Drivers:RTC 2.1.0, Device:StdPeriph Drivers:SPI 2.1.0, Device:StdPeriph Drivers:TIM 2.1.0, Device:StdPeriph Drivers:USART 2.1.0, Device:StdPeriph Drivers:WWDT 2.1.0
